## Buildroot/Config.in
```kconfig
config BR2_PACKAGE_FICL
	bool "ficl"
    default n
	help
	  A Forth Inspired Control Language.
```
